# Repository lindamao-waterloop/waterloop_electrical

## KiCad design Optical Ring Encoder/Optical Ring Encoder.kicad_pcb

Board: 2 copper layers, 46.4 x 25.6 mm, 30 parts (6 on the bottom side), 14 nets.

Parts:
C1, C2#2, C5#2, C7: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C9: 100p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4, C5: 20p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6, C9#2: 100u; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
J1: ISP-6; PinHeader_2x03_P2.54mm_Vertical
J2: Conn_01x04_Male; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R1: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 120; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R5: 80Ω; RESC1005X35N
R4, R6: 4.7k; RESC0603X26N
TP7, TP8, TP9, TP10, TP11: TestPoint; TestPoint_Pad_D1.0mm
U1: ATmega16M1-AU; TQFP-32_7x7mm_P0.8mm
U2: NCP1117-5V; SOT-223-3_TabPin2
U3: TJA1051T; SOIC-8_3.9x4.9mm_P1.27mm
U4: NCP1117-3.3V; SOT-223-3_TabPin2
U5, U5#2: OPB733TR
Y1: Crystal; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
3.3V: R3.1, R4.1, R5.1, R6.1
+3V3: C9#2.1, TP9.1
+5V: C1.1, C2.1, C5#2.1, C6.1, C7.1, TP7.1, U1.4, U1.19, U2.2, U3.3
/CANRX: U1.7, U3.4
/CANTX: U1.6, U3.1
/XTAL1: C4.1, U1.10, Y1.2
/XTAL2: U1.11, Y1.1
CANH: R2.1, U3.7
CANL: R2.2, U3.6
Earth: C1.2, C2.2, C4.2, C5#2.2, C6.2, C7.2, C9#2.2, TP8.1, U1.5, U1.20, U2.1, U3.2, U3.8
GND: U5.1, U5.2, U5#2.1, U5#2.2
unnamed: R3.2, U5.4, U5#2.4
PB5: R4.2, TP10.1, U1.26, U5.3, U5#2.3
PB6: R6.2, TP11.1, U1.27

## KiCad design Brake_Actuator/BrakeActuator.kicad_pcb

Parts:
C1, C2, C7: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4: 100u; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C5, C6: 10p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 100p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: D; D_SMA
J1: ISP-6; PinHeader_2x03_P2.54mm_Vertical
J2: Conn_01x04_Male; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
J3: 24V Connector; PinSocket_1x02_P2.54mm_Vertical
J4: Brake; PinSocket_1x02_P2.54mm_Vertical
Q1: STP55NF06L; TDSON-8-1
R1: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 100; R_0603_1608Metric
R3: 0; R_0603_1608Metric
R4: 100k; R_0603_1608Metric
R5: 50 mili; R_2512_6332Metric_Pad1.52x3.35mm_HandSolder
TP0, TP4, TP5, TP8: TestPoint; TestPoint_Pad_D1.0mm
U1: ATmega16M1-AU; TQFP-32_7x7mm_P0.8mm
U2: TJA1051T; SOIC-8_3.9x4.9mm_P1.27mm
U3: NCP1117-5V; SOT-223-3_TabPin2
U4: NCP1117-3.3V; SOT-223-3_TabPin2
U5: Sensor_Current_TSC888; SOT-23-5_HandSoldering
Y1: Crystal; Crystal_SMD_MicroCrystal_CC8V-T1A-2Pin_2.0x1.2mm

Connections:
+3V3: C2.1, C4.1, TP5.1, U4.2 (VO)
+5V: C1.1, C3.1, C7.1, C8.1, R1.1, TP4.1, U1.4 (VCC), U1.19 (AVCC), U2.3 (VCC), U3.2 (VO), U5.5 (Vcc)
+24V: J3.1, R3.1
/AMP1+: U1.18 (PC5)
/AMP1-: U1.17 (PC4)
/CANRX: U1.7 (PC3), U2.4 (RXD)
/CANTX: U1.6 (PC2), U2.1 (TXD)
/MISO: U1.8 (PB0)
/MISO_A: J1.1 (MISO), U1.1 (PD2)
/MOSI: U1.9 (PB1)
/MOSI_A: J1.4 (MOSI), U1.2 (PD3)
/RESET: J1.5 (~RST), R1.2, U1.31 (~RESET~/PE0); also elsewhere on the board
/SCK: U1.28 (PB7)
/SCK_A: J1.3 (SCK), U1.12 (PD4)
/XTAL1: C6.1, U1.10 (XTAL1/PE1), Y1.2
/XTAL2: C5.1, U1.11 (XTAL2/PE2), Y1.1
Brake+: D1.1 (K), J4.2, R5.2, U5.4 (Vm)
CANH: J2.3, U2.7 (CANH)
CANL: J2.4, U2.6 (CANL)
Earth: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.2 (A), J1.6 (GND), J2.2, J3.2, J4.1, R4.2, TP0.1, U1.5 (GND), U1.20 (AGND), U2.2 (GND), U2.8 (S), U3.1 (GND), U4.1 (GND), U5.2 (Gnd); also elsewhere on the board
unnamed: Q1.1 (S), Q1.2 (S), Q1.3 (S), R5.1, U5.3 (Vp)
unnamed: Q1.4 (G), R2.1
unnamed: Q1.5 (D), R3.2
OUT: R2.2, R4.1, U1.25 (PC7)
UIN: J1.2 (VCC), J2.1, U3.3 (VI), U4.3 (VI)

Notes on the sheet:
lindamao-waterloop/waterloop_electrical
18/01/2020
Delibird is the general design for the sensor CAN transciever. In order to transmit a sensor readout, you must either connect your sensor to the AtMega through SPI (digital sensors), or through an ADC/Differential amplifier pin (analog sensors).
Delibird

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
Board: 2 copper layers, 38.1 x 25.4 mm, 29 parts (9 on the bottom side), 21 nets.

Other parts of the board:
C9: 100p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Their connections:
/RESET: C9.1; also elsewhere on the board
Earth: C9.2; also elsewhere on the board

## KiCad design CAN_hub/CAN_hub.kicad_pcb

Parts:
J1, J2, J3, J4, J5, J6, J7, J8: Conn_01x04_Male; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical

Connections:
+5V: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1
CANH: J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3
CANL: J1.4, J2.4, J3.4, J4.4, J5.4, J6.4, J7.4, J8.4
GND: J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2

Board: 2 copper layers, 45.0 x 20.0 mm, 8 parts (0 on the bottom side), 4 nets.

## KiCad design RelayBoard/RelayBoard.kicad_pcb

Parts:
C1, C4, C5, C6, C7: 22uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C2, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3, C19, C20: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C22: 1000uF EEE-FT1A102AV; CP_Elec_8x10.5
D1: Diode; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1, FB2: Ferrite_Bead_Small; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: Micro_SD_Card; microSD_HC_Wuerth_693072010801
J2: Screw_Terminal_01x02; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J3: Conn_01x04_Male; JST_XH_B4B-XH-AM_1x04_P2.50mm_Vertical
J4, J10, J11, J12: 505004-0812; 5050040812; Mouser Part Number 538-505004-0812
J7, J8: SI-52008-F; BEL_SI-52008-F
J13: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
R1: 10kΩ; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2: 11.8kΩ, 1.0%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3, R4, R5, R6, R7, R8, R9, R10: 49.9Ω, 1.0%; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R11, R12, R13, R14: 60Ω; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R15: 300mΩ; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R16, R17: 4.7kΩ; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R18: 120Ω; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: STM32F745VEHx; TFBGA-100_8x8mm_Layout10x10_P0.8mm
U2: KSZ8863RLL; QFP50P900X900X160-48N
U3: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm
U4: LF33_TO252; TO-252-2
X1: ECS-2520SMV-250-GP-TR; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm

Connections:
3V3: C6.1, C10.1, C13.1, D1.1 (K), FB1.2, J1.4, J7.G_A, J7.Y_K, J8.G_A, J8.Y_K, R1.1, R16.2, R17.2, U1.B2 (VBAT), U1.D2 (VDD), U1.F4 (VDD), U1.F5 (VDD), U1.F6 (VDDUSB), U1.F7 (PDR_ON), U1.H1 (VDDA), U1.K1 (VDD), U2.22 (VDDIO), U2.40 (VDDIO), U3.5 (VIO), U4.3 (VO), X1.4 (VDD)
5V: C22.1, R15.1, U3.3 (VCC), U4.1 (VI)
5V_CAN: J3.1, J4.P1 (POWER_1), J4.P2 (POWER_2), J13.1, R15.2
24V: J2.2, J7.10 (VC+_P10), J8.10 (VC+_P10)
25MHz: U2.14 (X1), X1.3 (OUT)
CANRX: U1.D8 (PD0), U3.4 (RXD)
CANTX: U1.E8 (PD1), U3.1 (TXD)
CRS_DV: U1.K3 (PA7), U2.25 (SMRXDV3)
GND24: J2.1, J7.11 (VC-_P11), J8.11 (VC-_P11)
GNDC: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C22.2, H1.1, H2.1, J1.6, J1.MH1, J1.MH2, J3.4, J4.P3 (POWER_3), J4.P4 (POWER_4), J7.S1 (SHIELD), J7.S2 (SHIELD), J8.S1 (SHIELD), J8.S2 (SHIELD), J10.P1 (POWER_1), J10.P2 (POWER_2), J10.P3 (POWER_3), J10.P4 (POWER_4), J11.P1 (POWER_1), J11.P2 (POWER_2), J11.P3 (POWER_3), J11.P4 (POWER_4), J12.P1 (POWER_1), J12.P2 (POWER_2), J12.P3 (POWER_3), J12.P4 (POWER_4), J13.4, R2.2, U1.C2 (VSS), U1.D5 (BOOT0), U1.E4 (VSS), U1.E5 (VSS), U1.E6 (BYPASS_REG), U1.G1 (VSSA), U1.J1 (VSS), U2.10 (AGND), U2.21 (GND), U2.31 (GND), U2.41 (GND), U3.2 (GND), U3.8 (S), U4.2 (GND), X1.2 (GND)
MDC: U1.F2 (PC1), U2.36 (SCL_MDC)
MDIO: R16.1, U1.J2 (PA2), U2.37 (SDA_MDIO)
unnamed: C1.1, U1.E7 (VCAP_2)
unnamed: C2.2, U1.F8 (VCAP_1)
unnamed: C3.1, D1.2 (A), R1.2, U2.47 (~RSTN~)
unnamed: C15.1, R3.2, R5.2
unnamed: C16.1, R4.2, R6.2
unnamed: C17.1, R7.2, R9.2
unnamed: C18.1, R8.2, R10.2
unnamed: C19.1, J7.2 (COMMON_CT)
unnamed: C20.1, J8.2 (COMMON_CT)
unnamed: J7.G_K, R11.1
unnamed: J7.Y_A, R13.2
unnamed: J8.G_K, R12.1
unnamed: J8.Y_A, R14.2
unnamed: R2.1, U2.6 (ISET)
unnamed: R17.1, U2.39 (SPISN)
P1LED1: R11.2, U2.44 (P1LED0)
P1LED2: R13.1, U2.43 (P1LED1)
P2LED1: R12.2, U2.46 (P2LED0)
P2LED2: R14.1, U2.45 (P2LED1)
REF_CLK: U1.H2 (PA1), U2.23 (SMTXC3/REFCLKI_3), U2.26 (SMRXD33/REFCLKO_3)
RX1+: J7.4 (RD+), R9.1, U2.2 (RXP1)
RX1-: J7.5 (RD-), R7.1, U2.1 (RXM1)
RX2+: J8.4 (RD+), R10.1, U2.9 (RXP2)
RX2-: J8.5 (RD-), R8.1, U2.8 (RXM2)
RXD0: U1.G4 (PC4), U2.29 (SMRXD30)
RXD1: U1.H4 (PC5), U2.28 (SMRXD31)
SD_CLK: J1.5, U1.C8 (PC12)
SD_CMD: J1.3, U1.B7 (PD2)
SD_D0: J1.7, U1.F9 (PC8)
SD_D1: J1.8, U1.E9 (PC9)
SD_D2: J1.1, U1.B9 (PC10)
SD_D3: J1.2, U1.B8 (PC11)
SWCLK: J13.3, U1.A9 (PA14)
SWDIO: J13.2, U1.A10 (PA13)
TX1+: J7.1 (TD+), R5.1, U2.4 (TXP1)
TX1-: J7.3 (TD-), R3.1, U2.3 (TXM1)
TX2+: J8.1 (TD+), R6.1, U2.12 (TXP2)
TX2-: J8.3 (TD-), R4.1, U2.11 (TXM2)
TXD0: U1.K8 (PB12), U2.20 (SMTXD30)
TXD1: U1.J8 (PB13), U2.19 (SMTXD31)
TX_EN: U1.K7 (PB11), U2.16 (SMTXEN3)
VDDA_1.8: C7.1, C11.1, FB2.1, U2.7 (VDDA_1.8)
VDDA_3.3: C5.1, C9.1, FB1.1, U2.5 (VDDA_3.3)
VDDC: C4.1, C8.1, C12.1, C14.1, FB2.2, U2.32 (VDDC), U2.42 (VDDCO)

Notes on the sheet:
may need 75ohm to cap
where's the cable shield at

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
Board: 2 copper layers, 52.8 x 38.1 mm, 59 parts (4 on the bottom side), 58 nets.

## KiCad design Pressure_Sensor_updated/Pressure Updated Updated/Psyduck.kicad_pcb

Parts:
C1, C2, C7, C9: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4: 100u; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C5, C6: 20p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 100p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: ISP-6; PinHeader_2x03_P2.54mm_Vertical
J2: Conn_01x04_Male; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical
J3: Conn_01x03_Male; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
R1: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 120; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP0, TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_Pad_D1.0mm
U1: ATmega16M1-AU; TQFP-32_7x7mm_P0.8mm
U2: TJA1051T; SOIC-8_3.9x4.9mm_P1.27mm
U3: NCP1117-5V; SOT-223-3_TabPin2
U4: NCP1117-3.3V; SOT-223-3_TabPin2
Y1: Crystal; Crystal_SMD_MicroCrystal_CC8V-T1A-2Pin_2.0x1.2mm

Connections:
+3V3: C2.1, C4.1, TP5.1, U4.2 (VO)
+5V: C1.1, C3.1, C7.1, C8.1, C9.1, J1.2 (VCC), J3.1, R1.1, TP4.1, U1.4 (VCC), U1.19 (AVCC), U1.21 (AREF/ISRC), U2.3 (VCC), U3.2 (VO)
/AMP1+: TP7.1, U1.18 (PC5)
/AMP1-: TP6.1, U1.17 (PC4)
/CANRX: U1.7 (PC3), U2.4 (RXD)
/CANTX: U1.6 (PC2), U2.1 (TXD)
/MISO: TP1.1, U1.8 (PB0)
/MISO_A: J1.1 (MISO), U1.1 (PD2)
/MOSI: TP2.1, U1.9 (PB1)
/MOSI_A: J1.4 (MOSI), U1.2 (PD3)
/RESET: J1.5 (~RST), R1.2, U1.31 (~RESET~/PE0); also elsewhere on the board
/SCK: TP3.1, U1.28 (PB7)
/SCK_A: J1.3 (SCK), U1.12 (PD4)
/XTAL1: C6.1, U1.10 (XTAL1/PE1), Y1.2
/XTAL2: C5.1, U1.11 (XTAL2/PE2), Y1.1
CANH: J2.3, R2.1, U2.7 (CANH)
CANL: J2.4, R2.2, U2.6 (CANL)
Earth: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.6 (GND), J2.2, J3.2, TP0.1, U1.5 (GND), U1.20 (AGND), U2.2 (GND), U2.8 (S), U3.1 (GND), U4.1 (GND); also elsewhere on the board
OUTPUT+: J3.3, TP8.1, U1.13 (PD5)
UIN: J2.1, U3.3 (VI), U4.3 (VI)

Notes on the sheet:
lindamao-waterloop/waterloop_electrical
18/01/2020
Psyduck

Board: 2 copper layers, 38.1 x 25.4 mm, 29 parts (6 on the bottom side), 20 nets.

Other parts of the board:
C9#2: 100p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Their connections:
/RESET: C9#2.1; also elsewhere on the board
Earth: C9#2.2; also elsewhere on the board

## KiCad design RaspberryPi/Raspberry PI.kicad_pcb

Board: 2 copper layers, 11 parts (0 on the bottom side), 7 nets, no tracks yet.

Parts:
C1, C2: 22pF; CAPC0603X33N
C3, C4, C5: 0.1μF; CP_Elec_3x5.3
P1: Header20X2; PinHeader_2x20_P1.00mm_Vertical
U1: MCP25625; SOP65P780X200-28N
U2: BatteryConnector; Molex_CLIK-Mate_502382-0270_1x02-1MP_P1.25mm_Vertical
Y1: 16mHz; XTAL_ECS-160-20-3X-TR
p1, p2: Header2; PinHeader_1x02_P1.00mm_Vertical

Connections:
+3V3: C3.1, C5.1, U1.1, U1.19
+5V: C4.1, U1.27
GNDREF: C1.2, C2.2, C3.2, C4.2, C5.2, U1.10, U1.26
unnamed: C1.1, U1.8, Y1.1
unnamed: C2.1, U1.9, Y1.2
unnamed: U1.20, U1.24
unnamed: U1.21, U1.28

## Commit log

2020-01-15 Initial README.md commit
2020-01-15 Added general component library, including: - ATmega16M1 (IC) - ICSP header - JST_XH connector - TJA1050T (CAN Transceiver)
2020-01-16 Added changes to component library and general schematic v1
2020-01-16 Fixed TX/RX connections to CAN Transceiver
2020-01-18 General sensor to CAN board schematic
2020-01-18 Schematic has been cleaned up
2020-01-21 Add files via upload
    Tristan - Adding current sensing board
2020-01-25 Add files via upload
    High and Low pressure sensor use the same board.
    Delete old pressure sensor folder please.
2020-01-25 Laser Strip Sensor schematic
2020-01-25 Laser Stripe Sensor schematic
2020-01-28 Add files via upload
    fixed small bug
2020-02-01 Update Delibird.sch
    All footprints are consistent between Schematic and PCB, Specific decoupling capacitor for TJA1050 added
2020-02-01 [Tristan] - Addressed comments
2020-02-16 Add files via upload
    fixed pcb layout and updated gerber files
2020-02-17 Cleaned up repo, created Delibird and Chinchou directories
2020-02-29 Added IMU, and assigned footprint
2020-02-29 Added brake actuator files, updated Delibird
    Updated files are located under "Brake Actuator" folder.
2020-02-29 Added brake actuator files
2020-02-29 Update brake actuator
2020-02-29 Change to 10p
2020-02-29 Fixed footprints in BrakeActuator schematic and pcb
2020-03-09 Add RelayBoard schematic
2020-03-09 finished layout
2020-03-09 add jlcjlcjlcjlc
2020-03-09 Programming connector, CAN connectors 2.54mm
2020-03-09 replace pin jumper with solder jumper
2020-03-09 better solder jumper pad
2020-03-10 substantial rewiring after adding MDIO and MCL
2020-03-10 add polyfuse, check all RMII stuff, shorten diode trace
2020-03-10 partial rework of power - needs some bigger components oops
2020-03-10 Combined current sensor board to brake actuator
2020-03-11 ok give up on trying to regulate 24 to 5
2020-03-11 Updated shematic and layout to accomodate changes from first round of testing
2020-03-11 Finished layout and generated gerber files
2020-03-11 unnecessary but satisfying miniaturization
2020-03-12 cleanup; bump to v1.2
2020-03-12 ... and now it's even smaller.
2020-03-12 octopus!
2020-03-13 better grounding etc
2020-03-14 final edits during sourcing; submitted for printing
2020-03-17 test
2020-03-17 not ok
2020-03-24 most recent changes to brake actuator
2020-03-25 completed part for brake actuator board
2020-03-25 Transferred Psyduck and CANHUB to Altium
    Recreated Psyduck and CANHUB boards on Altium including the schematic, pcb layout and gerber files. Also includes the libraries made for the JST connectors and Voltage regulators, everything else can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
2020-06-13 Updated some library things.
2020-09-22 update relayboard
